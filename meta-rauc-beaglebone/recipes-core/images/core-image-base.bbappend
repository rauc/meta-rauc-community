require rauc-image.inc
