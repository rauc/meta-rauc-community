# ---
# RAUC system configuration

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"