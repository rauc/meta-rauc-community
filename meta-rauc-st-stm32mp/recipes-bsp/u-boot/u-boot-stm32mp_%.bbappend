FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://0001-configs-stm32mp15_defconfig-RAUC.patch \
"
