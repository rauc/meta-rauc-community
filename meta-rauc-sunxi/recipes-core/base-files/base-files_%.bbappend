FILESEXTRAPATHS:prepend:sun8i := "${THISDIR}/files:"
