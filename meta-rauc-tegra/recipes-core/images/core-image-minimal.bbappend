ROOTFSPART_SIZE:jetson-tx2-devkit = "15032385536"
ROOTFSPART_SIZE:jetson-nano-devkit-emmc = "7275020288"
